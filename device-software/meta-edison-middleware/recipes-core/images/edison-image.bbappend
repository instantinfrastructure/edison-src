IMAGE_INSTALL += "packagegroup-core-buildessential"

IMAGE_INSTALL += "zeromq zeromq-dev"
IMAGE_INSTALL += "rsmb"
IMAGE_INSTALL += "nodejs"
IMAGE_INSTALL += "paho-mqtt paho-mqtt-dev"
IMAGE_INSTALL += "mdns mdns-dev"
IMAGE_INSTALL += "iotkit-comm-js"
IMAGE_INSTALL += "iotkit-comm-c iotkit-comm-c-dev"
IMAGE_INSTALL += "iotkit-agent"
IMAGE_INSTALL += "xdk-daemon"
IMAGE_INSTALL += "oobe"

# MRAA
IMAGE_INSTALL += "mraa mraa-dev"
IMAGE_INSTALL += "mraa-doc"

# UPM
IMAGE_INSTALL += "upm upm-dev"
