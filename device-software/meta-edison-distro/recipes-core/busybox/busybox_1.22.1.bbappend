# to get brctl configuration settings
FILESEXTRAPATHS_prepend := "${THISDIR}/files/"

SRC_URI += "file://brctl-utilities.cfg"
